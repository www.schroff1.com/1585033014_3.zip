# Autodesk Inventor part: ex6-4
## iProperties
Created: 2006-03
Part Number: ex6-4
Document SubType Name: Modeling
Designer: Elise Moss
Author: Elise Moss
