# Autodesk Inventor part: ex6-2
## iProperties
Created: 2006-03
Part Number: ex6-2
Document SubType Name: Modeling
Designer: Elise Moss
Author: Elise Moss
