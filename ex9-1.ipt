# Autodesk Inventor part: ex9-1
## iProperties
Created: 2006-03
Part Number: ex9-1
Document SubType Name: Sheet Metal
Designer: Elise Moss
Author: Elise Moss
## Feature names
1. Plate1
2. Bend1
