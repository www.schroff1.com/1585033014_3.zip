# Autodesk Inventor part: ex7-1
## iProperties
Created: 2006-03
Part Number: ex7-1
Document SubType Name: Modeling
Designer: Elise Moss
Author: Elise Moss
## Feature names
1. Base1
