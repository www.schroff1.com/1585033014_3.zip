# Autodesk Inventor part: ex6-7
## iProperties
Created: 2006-03
Part Number: ex6-7
Document SubType Name: Modeling
Designer: Elise Moss
Author: Elise Moss
## Feature names
1. Extrusion1
